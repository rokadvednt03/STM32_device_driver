# Keil uVision project bluepill_uart_driver.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bluepill_uart_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: main.c
  group Driver
    ./: stm32f103xx_uart_driver.h stm32f103xx_uart_driver.c stm32f1030xx_gpio_driver.h stm32f103xx_gpio_driver.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
